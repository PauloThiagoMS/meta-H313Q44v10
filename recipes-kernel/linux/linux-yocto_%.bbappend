FILESEXTRAPATHS:prepend := "${THISDIR}:"

SRC_URI += "file://ethernet.cfg"
